Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: Project Number
Time: 2022-10-06T10:20:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.5.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 06 10:20:08 2022 * Host: HPZ2-TPLAT * Database: C:\Users\TESSAP~1\AppData\Local\Temp\{7C494860-7E28-44DD-8261-AE76A9A06EE7}\ifc * Database version: 5507 * Database creation date: Thu Oct 06 10:20:08 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 06 10:20:08 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 06 10:20:08 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - BCB_ProjectFolder: C:\Users\Tessa Plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\1. Betonkoppelsystemen\1202_DEMU Stekeind 2020; Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; BCB_ProjectFolder: C:\Users\Tessa Plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\1. Betonkoppelsystemen\1202_DEMU Stekeind 2020; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other - Category: Levels; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Identity Data(Type) - Type Name: Circle Head - Project Datum

# IfcBuildingElementProxy: 120220, NLRSnl_28_GM_WPB_1202-Stekeind-Bar end_Mavotrans_R19:120220_Ø16/M20x200:327596
In: Level 0
Type - Classification: 28.20 (Default Classification); Material: B500B according to EN 10080/NEN 6008
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - a min. (mm): 33 mm; d_nom: M20; L (mm): 200 mm; Lengte tolerantie | Tolerance length: +/- 20mm; Ø (mm): 16 mm; Type: 2020; Verankeringslengte | Anchorage length: 109mm
Type - Fire Protection - Brandklasse | Fire classification: Niet getest | Not rated
Type - Forces - Ontwerpbelasting | Design Loads: 87.4 kN
Type - Identity Data - Artikelnummer | Article number: 120220; Beschrijving | Description: DEMU Stekeind | Cutting end 2020 Ø16 M20 200mm; Certificaten | Certification: cat 1. K7044 | cat 2. K53316 | Eurocode 2; Laatste versie | Last version: 28-04-2022; Leverancier | Supplier: Mavotrans; Model: LOD400; NL-SfB code: 28.20; OmniClass Number: 23.25.10.27.11.11; OmniClass Title: Reinforcing Steel; Revisie | Revision: Rev0; Technische data | Technical Data: Raadpleeg de gekoppelde webpagina | Please refer to linked URL; Tekenaar | Draftsman: T. Plat; Type Name: 120220_Ø16/M20x200; URL: https://mavotrans.nl/demu-stekeind-2020.html; Verpakkingshoeveelheid | Sales Packaging: Verkoop per stuk | Sold per piece; Voorwaarden | Disclaimer: Raadpleeg de gekoppelde webpagina en controleer voor gebruik van dit BIM-model op de laatst beschikbare revisie. De modellen, geometrie, data en parameterwaarden zijn met de grootste zorg bepaald. Desalniettemin bestaat de mogelijkheid op onjuistheden. Elke aansprakelijkheid hiervoor wordt van de hand gewezen, hoewel melding op prijs wordt gesteld. © Mavotrans, 2022 | Please refer to linked URL and check for the latest available model revision. The models, geometry and parameter values have been determined with the greatest care. Still, they are subject to errors. Mavotrans cannot be held liable in any way. However, we do appreciate your feedback. © Mavotrans, 2022
Type - Materials and Finishes - Materiaal | Material: Betontaal B500B [EN 10080/NEN 6008]
Type - Other - Category: Generic Models; Diameter end rebar "M": 20 mm; Diameter rebar "Ø": 16 mm; Family Name: NLRSnl_28_GM_WPB_1202-Stekeind-Bar end_Mavotrans_R19; Length cutting end "L": 200 mm; Length minimal end cutting end "a": 33 mm; Radius "b": 10.5 mm; Radius "M": 10 mm; Radius "Ø": 8 mm; Radius "Ø" bar end: 10.5 mm; Transition: 8 mm
Type - Pset_ProductRequirements - Category: Generic Models
Description: DEMU Stekeind | Cutting end 2020 Ø16 M20 200mm
Pset_BuildingElementProxyCommon - Reference: NLRSnl_28_GM_WPB_1202-Stekeind-Bar end_Mavotrans_R19:120220_Ø16/M20x200; sets with these values: 2
Constraints - Level: Level: Level 0; Offset: 0 mm; Work Plane: Level : Level 0
Dimensions - Area: 0.00603028 m2; Volume: 0.0000443507 m3
Other - Family: NLRSnl_28_GM_WPB_1202-Stekeind-Bar end_Mavotrans_R19: 120220_Ø16/M20x200; Family and Type: NLRSnl_28_GM_WPB_1202-Stekeind-Bar end_Mavotrans_R19: 120220_Ø16/M20x200; Schedule Level: Level: Level 0; Type: NLRSnl_28_GM_WPB_1202-Stekeind-Bar end_Mavotrans_R19: 120220_Ø16/M20x200; Type Id: NLRSnl_28_GM_WPB_1202-Stekeind-Bar end_Mavotrans_R19: 120220_Ø16/M20x200
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover Settings: Rebar Cover 1
